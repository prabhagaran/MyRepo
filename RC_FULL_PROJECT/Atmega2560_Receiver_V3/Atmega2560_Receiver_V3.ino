#include <SPI.h>    //Comes with Arduino IDE
#include "RF24.h"   //Download and Install (See above)
#include <Servo.h>
#include <statusLED.h>
#include "steeringCurves.h"

#define  CE_PIN  7  //The pins to be used for CE and SN
#define  CSN_PIN 8

#define DEBUG

int Throttle = 1000;
int steeringServo =  1500;

int vehicleNumber = 1;

boolean left;
boolean right;
boolean hazard;


const int threshold = 50; // Threshold for center position
const int debounceDelay = 50; // Debounce time in milliseconds

int lastState = LOW; // Variable to store the last state of the switch
int lastDebounceTime = 0;


int Servo_POS = 90;
Servo ESC;
Servo SteeringServo;
Servo CH1;
Servo CH2;
Servo CH3;
Servo CH4;
Servo CH5;
Servo CH6;


statusLED headLight(false);
statusLED indicatorL(false);
statusLED indicatorR(false);
statusLED fogLight(false);
statusLED brakeLight(false);
statusLED backLight(false);
statusLED beacon(false);
statusLED beacon2(false);
statusLED topLight (false);
statusLED fairyLight (false);



const uint64_t pipeIn[] PROGMEM = {
  0xE9E8F0F0B1LL, 0xE9E8F0F0B2LL, 0xE9E8F0F0B3LL, 0xE9E8F0F0B4LL, 0xE9E8F0F0B5LL,
  0xE9E8F0F0B6LL, 0xE9E8F0F0B7LL, 0xE9E8F0F0B8LL, 0xE9E8F0F0B9LL, 0xE9E8F0F0B0LL,
  0xE9E8F0F0C1LL, 0xE9E8F0F0C2LL, 0xE9E8F0F0C3LL, 0xE9E8F0F0C4LL, 0xE9E8F0F0C5LL,
  0xE9E8F0F0C6LL, 0xE9E8F0F0C7LL, 0xE9E8F0F0C8LL, 0xE9E8F0F0C9LL, 0xE9E8F0F0C0LL
};
uint64_t pgm_read_64(const void *ptr, uint8_t index) {
  uint64_t result;
  memcpy_P( &result, (uint8_t*)ptr + (index * 8), sizeof(uint64_t) ); // ptr is counting in bytes!
  return result;
}

RF24 radio(CE_PIN, CSN_PIN);


void printDetail(uint8_t type, int value);

struct RcData {
  byte axis1; // Aileron (Steering for car)
  byte axis2; // Elevator
  byte axis3; // Throttle
  byte axis4; // Rudder
  byte pot1;
  byte pot2;

};
RcData data;                //This can be accessed in the form:  myData.Xposition  etc.

struct dataStruct1 {     //This is the NRF data sent out by the Slave. Max of 32 bytes
  float vcc; // vehicle vcc voltage
  float batteryVoltage; // vehicle battery voltage
  boolean batteryOk = true; // the vehicle battery voltage is OK!
  byte channel = 1; // the channel number
} myTele;


void RadioSetup()
{
  //NRF Setup//
  radio.begin();                   //Initialize the nRF24L01 Radio
  radio.setChannel(108);           //Above most WiFi frequencies
  radio.setDataRate(RF24_250KBPS); //Fast enough.. Better range
  radio.setPALevel(RF24_PA_MAX);//PA (Power Amplifier) Level can be one of four levels: RF24_PA_MIN, RF24_PA_LOW, RF24_PA_HIGH and RF24_PA_MAX
  radio.setAutoAck(pgm_read_64(&pipeIn, vehicleNumber - 1), true);
  radio.enableAckPayload();
  radio.enableDynamicPayloads();
  radio.setRetries(5, 5);
  radio.openReadingPipe(1, pgm_read_64(&pipeIn, vehicleNumber - 1));
  radio.writeAckPayload(1, &myTele, sizeof(myTele)); //pre-load data for transmission
  radio.startListening();

}

void setup() {
  data.axis1 = 50; // Aileron (Steering for car)
  data.axis2 = 50; // Elevator
  data.axis3 = 50; // Throttle
  data.axis4 = 50; // Rudder

  Serial.begin(115200);
  Serial1.begin(115200);
  ESC.attach(5);
  SteeringServo.attach(6);

  CH1.attach(11);
  CH2.attach(10);
  CH3.attach(9);
  CH4.attach(12);
  CH5.attach(3);
  CH6.attach(4);


  headLight.begin(2);
  topLight.begin(22);
  indicatorL.begin(23);
  indicatorR.begin(24);
  fogLight.begin(13);
  brakeLight.begin(26);
  backLight.begin(25);
  beacon.begin(27);
  beacon2.begin(28);
  fairyLight.begin(29);

  RadioSetup();

  myTele.vcc = 7.4;
  myTele.batteryVoltage = 3.3;
  myTele.batteryOk = true;
  myTele.channel = 1;
  ESC.writeMicroseconds(1000);
  CH1.writeMicroseconds(1500);
  CH2.writeMicroseconds(1500);
  CH3.writeMicroseconds(1500);
  CH4.writeMicroseconds(1500);
  CH5.writeMicroseconds(1500);
  CH6.writeMicroseconds(1500);
  delay(2000);

}

void ReadRadio()
{
  static unsigned long lastRecvTime = 0;
  if ( radio.available() ) {
    radio.writeAckPayload(1, &myTele, sizeof(myTele));  //Send acknowledge data back
    radio.read( &data, sizeof(data) );              //If data is available, read the data
    lastRecvTime = millis();

    if (millis() - lastRecvTime > 1000) { // set all analog values to their middle position, if no RC signal is received during 1s!
      data.axis1 = 50; // Aileron (Steering for car)
      data.axis2 = 50; // Elevator
      data.axis3 = 50; // Throttle
      data.axis4 = 50; // Rudder
      //hazard = true; // Enable hazard lights
      myTele.batteryOk = true; // Clear low battery alert (allows to re-enable the vehicle, if you switch off the transmitter)
#ifdef DEBUG
      Serial.println("No Radio Available - Check Transmitter!");
#endif
    }


  }
}

void led()
{
  if (Throttle >= 1400  && Throttle <= 1500)
  {
    brakeLight.on();
  } else
  {
    brakeLight.off();
  }


  if (data.axis4 < 5) left = true;
  if (data.axis4 >  55)left = false;
  if (data.axis4 > 95)right =  true;
  if (data.axis4 < 45) right =  false;

  static int steeringOld;

  if (data.axis1 > steeringOld + 10)
  {
    left =  false;
    steeringOld = data.axis1;
  }
  if (data.axis1 < steeringOld - 10)
  {
    right = false;
    steeringOld =  data.axis1;
  }

  if (left)
  {
    right =  false;
    indicatorL.flash(375, 375, 0, 0);
    indicatorR.off();
    //Serial.println("left");
  }
  if (right)
  {
    left =  false;
    indicatorR.flash(375, 375, 0, 0);
    indicatorL.off();
    //Serial.println("right");
  }

  if (data.axis3 > 55) hazard =  true;
  if (data.axis3 < 45) hazard =  false;

  if (hazard) { // Hazard lights
    if (left) {
      left = false;
      indicatorL.off();
    }
    if (right) {
      right = false;
      indicatorR.off();
    }
    indicatorL.flash(375, 375, 0, 0);
    indicatorR.flash(375, 375, 0, 0);
    //myDFPlayer.play(1);

    CH5.writeMicroseconds(2000);
  }

  if (!hazard && !left && !right) {
    indicatorL.off();
    indicatorR.off();
    CH5.writeMicroseconds(1500);
  }

  if (data.pot1 <= 10)
  {
    headLight.off();
    backLight.off();
    fogLight.off();
  }
  else if(data.pot1 >= 10 && data.pot1 <= 50)
  {
    headLight.flash(50, 80, 700, 10, 70);
     fogLight.flash(50, 80, 700, 10, 70);
   
  }
  else if (data.pot1 >= 50 && data.pot1 <= 75)
  {
    headLight.pwm(50);
    fogLight.off();
    if (data.axis1 <= 45)
    {
      backLight.on();

    }
    else
    {
      backLight.off();
    }
  }
  else if (data.pot1 >= 75 && data.pot1 <= 85 )
  {
    headLight.pwm(255);
    fogLight.off();

    if (data.axis1 <= 45)
    {
      backLight.on();

    }
    else
    {
      backLight.off();
    }

  }
  else if (data.pot1 >= 85)
  {
    headLight.pwm(255);
    fogLight.on();

    if (data.axis1 <= 45)
    {
      backLight.on();

    }
    else
    {
      backLight.off();
    }

  }
  else if (data.pot1 >= 80)
  {
    fogLight.on();
  }
  if (data.pot2 <= 10)
  {
    fairyLight.off();
    topLight.off();
    beacon.off();
    beacon2.off();
  }
  else if (data.pot2 >= 10 && data.pot2 <= 20)
  {
    fairyLight.flash(140, 150, 700, 5, 70);
    topLight.off();
    beacon.off();
    beacon2.off();
  }
  else if (data.pot2 >= 20 && data.pot2 <= 30)
  {
    fairyLight.flash(50, 80, 700, 10, 70);
    topLight.off();
    beacon.off();
    beacon2.off();
  }
  else if (data.pot2 >= 30 && data.pot2 <= 40)
  {
    fairyLight.flash(50, 80, 700, 10, 70);
    topLight.flash(50, 80, 700, 10, 70);
    beacon.off();
    beacon2.off();
  }
  else if (data.pot2 >= 40 && data.pot2 <= 50)
  {
    fairyLight.flash(50, 650, 0, 0);
    topLight.flash(50, 650, 0, 0);
    beacon.off();
    beacon2.off();
  }
   else if (data.pot2 >= 50 && data.pot2 <= 60)
  {
    fairyLight.flash(50, 650, 0, 0);
    topLight.off();
    beacon.off();
    beacon2.off();
  }
  else if (data.pot2 >= 60 && data.pot2 <= 70)
  {
    fairyLight.off();
    topLight.flash(50, 80, 700, 10, 70);
    beacon.off();
    beacon2.off();
  }
  else if (data.pot2 >= 70 && data.pot2 <= 80)
  {
    fairyLight.off();
    topLight.off();
    beacon.flash(50, 650, 0, 0);
    beacon2.flash(50, 650, 0, 0);
  }
  else if (data.pot2 >= 80 && data.pot2 <= 90)
  {
    fairyLight.off();
    topLight.flash(50, 80, 700, 10, 70);
   beacon.flash(50, 650, 0, 0);
    beacon2.flash(50, 650, 0, 0);
  }
  
  if (data.pot2 >= 90)
  {


    fairyLight.flash(140, 150, 700, 5, 70);
    topLight.flash(50, 80, 700, 10, 70);
    beacon.flash(50, 650, 0, 0);
    beacon2.flash(50, 650, 0, 0);

  }
}

void WriteServos()
{
  //Throttle  = map(data.axis1, 0, 100, 1000, 2000);
  steeringServo = map(data.axis4, 0 , 100, 1000, 2000);
  int steering1 = map(data.axis4, 0, 100, 2000, 1000);
  int ch2 = map(data.axis2, 0, 100, 1000, 2000);
  int ch3 = map(data.axis3, 0, 100, 1000, 2000);
  int ch4 =  map(data.axis4, 0, 100, 1000, 2000);

  uint16_t servo3Microseconds = 1500;
  static uint16_t servo3Microseconds2 = 1500;
  static long previousThrottleRampMillis;

  if (millis() - previousThrottleRampMillis >= 3) {
    previousThrottleRampMillis = millis();
    servo3Microseconds = map(data.axis1, 100, 0, 2000, 1000);
    servo3Microseconds = reMap(curveExponentialThrottle, servo3Microseconds);
    if (servo3Microseconds2 < servo3Microseconds) servo3Microseconds2 ++;
    if (servo3Microseconds2 > servo3Microseconds) servo3Microseconds2 --;
    Throttle  = servo3Microseconds2 ;
    ESC.writeMicroseconds(Throttle);
  }


  //EngineSound.writeMicroseconds(steering1);
  SteeringServo.writeMicroseconds(steeringServo);
  CH1.writeMicroseconds(Throttle);
  CH2.writeMicroseconds(ch4);
  CH3.writeMicroseconds(ch3);
  CH4.writeMicroseconds(ch2);
  //CH5.writeMicroseconds(ch3);
  CH6.writeMicroseconds(ch3);


}


void loop()
{

  ReadRadio();
  WriteServos();
  led();

  static unsigned long timer = millis();

  if (millis() - timer > 100) {
    timer = millis();
    Serial1.write((uint8_t*)&data, sizeof(data));
  }

#ifdef DEBUG
  Serial.print(Throttle);
  Serial.print("\t");
  Serial.print(data.axis2);
  Serial.print("\t");
  Serial.print(data.axis3);
  Serial.print("\t");
  Serial.print(data.axis4);
  //Serial.print("\t");
  //Serial.print(left);
  Serial.print("\t");
  Serial.print(data.pot1);
  Serial.print("\t");
  Serial.print(data.pot2);
  Serial.print("\t");
  Serial.println();
#endif

}
